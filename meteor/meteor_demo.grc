options:
  parameters:
    author: HA7NCS
    category: '[Meteor]'
    comment: |-
      Meteor M-N 2.x LRPT (72k) OQPSK demodulator to process signals 
      captured at 137.9 or 137.1 MHz.

      Accepts complex float32 (cf32) IQ input. 

      Set sample rate parameter to your input!
    copyright: Copyright (c) 2026 David Nemeth-Csoka
    description: Meteor M-N2 LRPT (72k) OQPSK demodulator
    generate_options: qt_gui
    id: meteor_demod
    output_language: python
    title: Meteor M N 2-x ,72k LRPT demodulator
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/encse/projects/radio/2026-03-15_11-49-20_166666SPS_137900000Hz.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: ccsds_image_decoder_0
  id: ccsds_image_decoder
  parameters: {}
  states: {}
- name: ccsds_image_decoder_0_0
  id: ccsds_image_decoder
  parameters: {}
  states: {state: disabled}
- name: ccsds_image_viewer_0
  id: ccsds_image_viewer
  parameters:
    gui_hint: 0,1,4,1
    width: '1568'
  states: {}
- name: ccsds_image_viewer_0_0
  id: ccsds_image_viewer
  parameters:
    width: '1568'
  states: {state: disabled}
- name: meteor_lrpt_0
  id: meteor_lrpt
  parameters:
    sample_rate: sample_rate
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    color1: '"red"'
    gui_hint: 0,0,3,1
    legend: 'False'
    name: Constellation
    size: '4000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: BER
    min: '0'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Frequency
    min: '0'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: SNR (dB)
    min: '0'
    name: ''
    type: float
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Input sample rate
    type: intx
    value: '166666'
  states: {}

connections:
- [blocks_file_source_0, '0', meteor_lrpt_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [ccsds_image_decoder_0, out, ccsds_image_viewer_0, in]
- [ccsds_image_decoder_0_0, out, ccsds_image_viewer_0_0, in]
- [meteor_lrpt_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [meteor_lrpt_0, '1', qtgui_number_sink_0, '0']
- [meteor_lrpt_0, '2', qtgui_number_sink_0_0, '0']
- [meteor_lrpt_0, '3', qtgui_number_sink_0_1, '0']
- [meteor_lrpt_0, msu_mr_1, ccsds_image_decoder_0, in]
- [meteor_lrpt_0, msu_mr_4, ccsds_image_decoder_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
