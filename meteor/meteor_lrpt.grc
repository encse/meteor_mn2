options:
  parameters:
    category: '[Meteor]'
    generate_options: hb
    id: meteor_lrpt
    output_language: python
    title: Meteor M N 2.x LRPT 72k
  states: {}

blocks:
- name: ccsds_apid_filter_0
  id: ccsds_apid_filter
  parameters:
    apid: '64'
  states: {}
- name: ccsds_apid_filter_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '65'
  states: {}
- name: ccsds_apid_filter_0_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '66'
  states: {}
- name: ccsds_apid_filter_0_0_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '67'
  states: {}
- name: ccsds_apid_filter_0_0_0_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '68'
  states: {}
- name: ccsds_apid_filter_0_0_0_0_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '69'
  states: {}
- name: ccsds_apid_filter_0_0_0_0_0_0_0
  id: ccsds_apid_filter
  parameters:
    apid: '70'
  states: {}
- name: ccsds_channel_decoder_0
  id: ccsds_channel_decoder
  parameters: {}
  states: {}
- name: oqpsk_demodulator_0
  id: oqpsk_demodulator
  parameters:
    sample_rate: sample_rate
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: msu_mr_1
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: msu_mr_2
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: msu_mr_3
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_2
  id: pad_sink
  parameters:
    label: msu_mr_4
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_3
  id: pad_sink
  parameters:
    label: msu_mr_5
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_3_0
  id: pad_sink
  parameters:
    label: msu_mr_6
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_5
  id: pad_sink
  parameters:
    label: telemetry
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: BER
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_1
  id: pad_sink
  parameters:
    label: doppler_hz
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_1_0
  id: pad_sink
  parameters:
    label: snr_db
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: input
    type: complex
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: space_packet_assembler_0
  id: space_packet_assembler
  parameters: {}
  states: {}
- name: vcdu_parser_0
  id: vcdu_parser
  parameters: {}
  states: {}

connections:
- [ccsds_apid_filter_0, out, pad_sink_0, in]
- [ccsds_apid_filter_0_0, out, pad_sink_0_0, in]
- [ccsds_apid_filter_0_0_0, out, pad_sink_0_1, in]
- [ccsds_apid_filter_0_0_0_0, out, pad_sink_0_2, in]
- [ccsds_apid_filter_0_0_0_0_0, out, pad_sink_0_3, in]
- [ccsds_apid_filter_0_0_0_0_0_0, out, pad_sink_0_3_0, in]
- [ccsds_apid_filter_0_0_0_0_0_0_0, out, pad_sink_0_5, in]
- [ccsds_channel_decoder_0, '0', pad_sink_1_0, '0']
- [ccsds_channel_decoder_0, cadus, vcdu_parser_0, in]
- [oqpsk_demodulator_0, '0', ccsds_channel_decoder_0, '0']
- [oqpsk_demodulator_0, '0', pad_sink_1, '0']
- [oqpsk_demodulator_0, '1', pad_sink_1_1, '0']
- [oqpsk_demodulator_0, '2', pad_sink_1_1_0, '0']
- [pad_source_0, '0', oqpsk_demodulator_0, '0']
- [space_packet_assembler_0, out, ccsds_apid_filter_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0_0_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0_0_0_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0_0_0_0_0, in]
- [space_packet_assembler_0, out, ccsds_apid_filter_0_0_0_0_0_0_0, in]
- [vcdu_parser_0, out, space_packet_assembler_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
